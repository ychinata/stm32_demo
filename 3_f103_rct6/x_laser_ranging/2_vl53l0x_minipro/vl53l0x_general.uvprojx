# Keil uVision project vl53l0x_general.uvprojx, settings and files
target STM32 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: vl53l0x_general +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\LED;.\lib\inc;.\startup;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\USER;.\VL53L0X\core\inc;.\VL53L0X\platform\inc;.\VL53L0X\demo;.\HARDWARE\TFT1.44;.\HARDWARE\VL53L0X\core\inc;.\HARDWARE\VL53L0X\demo;.\HARDWARE\VL53L0X\platform\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group lib
    ./lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group startup
    ./startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group led
    ./LED/: led.c
  group user
    ./USER/: main.c
  group sys
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group Hardware
    ./HARDWARE/TFT1.44/: GUI.c Lcd_Driver.c TFT_demo.c
    ./HARDWARE/VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ./HARDWARE/VL53L0X/demo/: vl53l0x.c vl53l0x_gen.c vl53l0x_it.c
    ./HARDWARE/VL53L0X/platform/src/: vl53l0x_i2c.c vl53l0x_platform.c
